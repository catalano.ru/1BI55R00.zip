Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Bidets_Ceramica-Catalano_NEW-ZERO-Bidet-T-55-traslato.ifc
Time: 2023-03-23T09:37:38
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: NEW ZERO Bidet T 55 traslato
ePset_BIMobjectScript - BIDET_COLOUR: Glossy_White; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): NEW ZERO Bidet T 55 traslato; SKU (BO_prodsku): new-zero-bidet-t-55-traslato; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/new-zero-bidet-t-55-traslato; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/new-zero-bidet-t-55-traslato; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Bidets; BimObjectCategoryCode (BO_bocat_code): sanitary-bidets; IfcClassification (BO_ifcclas): Sanitary Terminal; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
